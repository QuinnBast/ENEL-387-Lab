# Keil uVision project Mp3 Play Station.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mp3 Play Station
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ../Libraries/: GPIO_lib.c GPIO_lib.h LCD.c LCD.h
    ./: main.c MP3Trigger.c MP3Trigger.h PS2.h PS2.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
